# Keil uVision project AD_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: AD_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 PWM.c
