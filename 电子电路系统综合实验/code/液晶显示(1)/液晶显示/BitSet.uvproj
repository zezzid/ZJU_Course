# Keil uVision project BitSet.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C58 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(24000000)
  output: Display +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 SRTT_II main.c STC12C.h
