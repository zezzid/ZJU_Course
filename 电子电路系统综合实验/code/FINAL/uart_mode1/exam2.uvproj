# Keil uVision project exam2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5616AD STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FF) IROM(0-0x3FFF) CLOCK(45000000)
  output: exam2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: exam2.c
